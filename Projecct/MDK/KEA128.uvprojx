# Keil uVision project KEA128.uvprojx, settings and files
target KEA128 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.2.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: KEA128
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\USER\inc;..\USER\src;..\..\Libraries\drives\inc;..\..\Libraries\drives\src;..\..\Libraries\seekfree;..\..\Libraries\startup\CoreSupport;..\..\Libraries\startup;..\..\Libraries\startup\DeviceSupport;..\..\Libraries\startup\DeviceSupport\MDK-ARM;..\WD151
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group startup
    ../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_SKEAZ1284.s
    ../../Libraries/startup/DeviceSupport/: system_SKEAZ1284.c system_SKEAZ1284.h
  group drives_c
    ../../Libraries/drives/src/: misc.c common.c KEA128_adc.c KEA128_flash.c KEA128_ftm.c KEA128_gpio.c KEA128_irq.c KEA128_kbi.c KEA128_pit.c KEA128_port.c KEA128_uart.c KEA128_systick.c KEA128_i2c.c KEA128_spi.c
  group drives_h
    ../../Libraries/drives/inc/: common.h headfile.h KEA128_adc.h KEA128_flash.h KEA128_ftm.h KEA128_gpio.h KEA128_i2c.h KEA128_irq.h KEA128_kbi.h KEA128_pit.h KEA128_port.h KEA128_port_cfg.h KEA128_spi.h KEA128_systick.h KEA128_uart.h misc.h
  group seekfree
    ../../Libraries/seekfree/: font.c font.h SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_OLED.c SEEKFREE_OLED.h
  group user_c
    ../USER/src/: isr.c main.c
    ../../Libraries/: version.txt
    ../../Libraries/drives/inc/: KEA128_port_cfg.h
  group user_h
    ../../Libraries/drives/inc/: headfile.h
    ../USER/inc/: isr.h
  group WD151
    ../WD151/: System.c loop.c loop.h Control.c Control.h PID.c PID.h EM.c EM.h Search.c Search.h filter.c filter.h MPU6050.c MPU6050.h led.c led.h ADRC.c ADRC.h ANO_Data_Transfer.c ANO_Data_Transfer.h show.c show.h mymath.c mymath.h My_I2C.c
